FILESEXTRAPATHS_prepend_sawshark := "${THISDIR}/libhybris:"
SRCREV_sawshark = "8883e9aca7de870a4a93b31e82cfc600c51cef5d"
SRC_URI_append_sawshark = " file://0001-test_vibrator-Remove-header-check.patch;striplevel=2"
